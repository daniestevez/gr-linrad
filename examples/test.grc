<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>384000</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>amp</key><value>1e-1</value></param>
<param><key>freq</key><value>10e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>0.0</value></param>
<param><key>noise_voltage</key><value>1e-4</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0</value></param>
</block>
<block>
<key>linrad_send_raw24</key>
<param><key>id</key><value>linrad_send_raw24_0</value></param>
<param><key>base_port</key><value>50000</value></param>
<param><key>bufsize</key><value>0x1000</value></param>
<param><key>ip</key><value>"127.0.0.1"</value></param>
<param><key>passband_center</key><value>10.0</value></param>
</block>
<block>
<key>linrad_server</key>
<param><key>id</key><value>linrad_server_0</value></param>
<param><key>ad</key><value>2</value></param>
<param><key>buf</key><value>0x1000</value></param>
<param><key>iq</key><value>True</value></param>
<param><key>ip</key><value>"0.0.0.0"</value></param>
<param><key>rf</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>linrad_send_raw24_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
