options:
  parameters:
    author: Daniel Estévez
    generate_options: qt_gui
    id: test
    output_language: python
    title: gr-linrad test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '384000'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1e-1'
    freq: 10e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '1e-4'
    seed: '0'
    taps: '1.0'
  states: {}
- name: linrad_send_raw24_0
  id: linrad_send_raw24
  parameters:
    base_port: '52000'
    bufsize: '0x1000'
    ip: '"127.0.0.1"'
    passband_center: '10.0'
  states: {}
- name: linrad_server_0
  id: linrad_server
  parameters:
    ad: '2'
    buf: '0x1000'
    dword: 'True'
    ip: '"0.0.0.0"'
    iq: 'True'
    rf: '1'
    samp_rate: samp_rate
  states: {}

connections:
- [analog_sig_source_x_1, '0', blocks_throttle_1, '0']
- [blocks_throttle_1, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', linrad_send_raw24_0, '0']

metadata:
  file_format: 1
